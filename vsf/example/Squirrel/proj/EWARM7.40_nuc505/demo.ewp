# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: NUC505 series Nuvoton NUC505 series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: FLASH_LOAD_OFFSET=0x0
  ICCARM.CCDiagSuppress: Pa050,Pe301
  ICCARM.CCIncludePath2: ; ..\..; ..\..\config; ..\..\squirrel3\include; ..\..\..\..; ..\..\..\..\compiler\IAR; ..\..\..\..\hal; ..\..\..\..\hal\cpu\nuc505
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: nuc505.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FLASH_LOAD_OFFSET=0x0
  ICCARM.CCIncludePath2: ; ..\..; ..\..\config; ..\..\..\..; ..\..\..\..\compiler\IAR; ..\..\..\..\hal; ..\..\..\..\hal\cpu\nuc505
  ICCARM.CCOptLevel: 3
  group (top)
    ../../: usbd_config.c usrapp.c usrapp.h
  group config
    ./: app_cfg.h vsfhal_cfg.h
    ../../config/: vsf_cfg.h
  group shell_cmd
    ../../shell_cmd/: cdcuart.c cdcuart.h help.c help.h sq.c sq.h sqmem.cpp
  group squirrel3/include
    ../../squirrel3/include/: sqconfig.h sqstdaux.h sqstdblob.h sqstdio.h sqstdmath.h sqstdstring.h sqstdsystem.h squirrel.h
  group squirrel3/sqstdlib
    ../../squirrel3/sqstdlib/: sqstdaux.cpp sqstdblob.cpp sqstdblobimpl.h sqstdio.cpp sqstdmath.cpp sqstdrex.cpp sqstdstream.cpp sqstdstream.h sqstdstring.cpp sqstdsystem.cpp
  group squirrel3/squirrel
    ../../squirrel3/squirrel/: sqapi.cpp sqarray.h sqbaselib.cpp sqclass.cpp sqclass.h sqclosure.h sqcompiler.cpp sqcompiler.h sqdebug.cpp sqfuncproto.h sqfuncstate.cpp sqfuncstate.h sqlexer.cpp sqlexer.h sqmem.cpp sqobject.cpp sqobject.h sqopcodes.h sqpcheader.h sqstate.cpp sqstate.h sqstring.h sqtable.cpp sqtable.h squserdata.h squtils.h sqvm.cpp sqvm.h
  group vsf
    ../../../../: app_type.h vsf.h vsf_err.h vsfmain.c
  group vsf/compiler
    ../../../../compiler/IAR/: compiler.c compiler.h
  group vsf/component/crypto/crc
    ../../../../component/crypto/crc/: crc.c crc.h
  group vsf/component/debug
    ../../../../component/debug/: debug.c debug.h
  group vsf/component/fakefat32
    ../../../../component/fakefat32/: fakefat32.c fakefat32.h
  group vsf/component/file
    ../../../../component/file/: vsfile.c vsfile.h
  group vsf/component/file/fs/malfs
    ../../../../component/file/fs/malfs/: vsf_malfs.c vsf_malfs.h
  group vsf/component/file/fs/malfs/fat
    ../../../../component/file/fs/malfs/fat/: vsffat.c vsffat.h
  group vsf/component/fundation/bittool
    ../../../../component/fundation/bittool/: bittool.c bittool.h
  group vsf/component/fundation/buffer
    ../../../../component/fundation/buffer/: buffer.c buffer.h
  group vsf/component/fundation/list
    ../../../../component/fundation/list/: list.c list.h
  group vsf/component/fundation/stream
    ../../../../component/fundation/stream/: stream.c stream.h
  group vsf/component/mal
    ../../../../component/mal/: vsfmal.c vsfmal.h vsfscsi.c vsfscsi.h
  group vsf/component/mal/drivers/embflash
    ../../../../component/mal/drivers/embflash/: embflash.c embflash.h
  group vsf/component/shell
    ../../../../component/shell/: vsfshell.c vsfshell.h
  group vsf/component/stream/usart_stream
    ../../../../component/stream/usart_stream/: usart_stream.c usart_stream.h
  group vsf/component/usb/class/common/CDC
    ../../../../component/usb/class/common/CDC/: vsfusb_CDC.h vsfusb_CDCACM.h vsfusb_RNDIS.h
  group vsf/component/usb/class/common/MSC
    ../../../../component/usb/class/common/MSC/: vsfusb_MSC.h
  group vsf/component/usb/class/device/CDC
    ../../../../component/usb/class/device/CDC/: vsfusbd_CDC.c vsfusbd_CDC.h vsfusbd_CDCACM.c vsfusbd_CDCACM.h vsfusbd_RNDIS.c vsfusbd_RNDIS.h
  group vsf/component/usb/class/device/MSC
    ../../../../component/usb/class/device/MSC/: vsfusbd_MSC_BOT.c vsfusbd_MSC_BOT.h
  group vsf/component/usb/class/device/VLLINK
    ../../../../component/usb/class/device/VLLINK/: vsfusbd_VLLINK.c vsfusbd_VLLINK.h
  group vsf/component/usb/class/host/HID
    ../../../../component/usb/class/host/HID/: vsfusbh_HID.c vsfusbh_HID.h
  group vsf/component/usb/class/host/HUB
    ../../../../component/usb/class/host/HUB/: vsfusbh_HUB.c vsfusbh_HUB.h
  group vsf/component/usb/class/host/UVC
    ../../../../component/usb/class/host/UVC/: vsfusbh_UVC.c vsfusbh_UVC.h
  group vsf/component/usb/common
    ../../../../component/usb/common/: usb_ch11.h usb_ch9.h usb_common.c usb_common.h usb_type.h
  group vsf/component/usb/core
    ../../../../component/usb/core/: vsfusbd.c vsfusbd.h vsfusbh.c vsfusbh.h
  group vsf/component/usb/core/hcd
    ../../../../component/usb/core/hcd/: hcd.h
  group vsf/component/usb/core/hcd/ohci
    ../../../../component/usb/core/hcd/ohci/: vsfohci.c vsfohci.h vsfohci_priv.h
  group vsf/framework/vsfsm
    ../../../../framework/vsfsm/: vsfsm.c vsfsm.h
  group vsf/framework/vsftimer
    ../../../../framework/vsftimer/: vsftimer.c vsftimer.h
  group vsf/hal
    ../../../../hal/: vsfhal.c vsfhal.h
  group vsf/hal/cpu/nuc505
    ../../../../hal/cpu/nuc505/: core.c core.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h NUC505Series.h vsf_basetype.h vsfhal_const.h
  group vsf/hal/cpu/nuc505/adc
    ../../../../hal/cpu/nuc505/adc/: NUC505_ADC.c NUC505_ADC.h
  group vsf/hal/cpu/nuc505/eint
    ../../../../hal/cpu/nuc505/eint/: NUC505_EINT.c NUC505_EINT.h
  group vsf/hal/cpu/nuc505/flash
    ../../../../hal/cpu/nuc505/flash/: NUC505_FLASH.c NUC505_FLASH.h spiflash_drv.c spiflash_drv.h spim.h
  group vsf/hal/cpu/nuc505/gpio
    ../../../../hal/cpu/nuc505/gpio/: NUC505_GPIO.c NUC505_GPIO.h
  group vsf/hal/cpu/nuc505/i2c
    ../../../../hal/cpu/nuc505/i2c/: NUC505_I2C.c NUC505_I2C.h
  group vsf/hal/cpu/nuc505/ohci
    ../../../../hal/cpu/nuc505/ohci/: NUC505_OHCI.c NUC505_OHCI.h
  group vsf/hal/cpu/nuc505/sdio
    ../../../../hal/cpu/nuc505/sdio/: NUC505_SDIO.c NUC505_SDIO.h
  group vsf/hal/cpu/nuc505/spi
    ../../../../hal/cpu/nuc505/spi/: NUC505_SPI.c NUC505_SPI.h
  group vsf/hal/cpu/nuc505/startup
    ../../../../hal/cpu/nuc505/startup/IAR/: startup_NUC505Series.s
  group vsf/hal/cpu/nuc505/timer
    ../../../../hal/cpu/nuc505/timer/: NUC505_TIMER.c NUC505_TIMER.h
  group vsf/hal/cpu/nuc505/uart
    ../../../../hal/cpu/nuc505/uart/: NUC505_USART.c NUC505_USART.h
  group vsf/hal/cpu/nuc505/usbd
    ../../../../hal/cpu/nuc505/usbd/: NUC505_USBD.c NUC505_USBD.h
