# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: NUC400AE series Nuvoton NUC400AE series (NUC442AE,NUC472AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: FLASH_LOAD_OFFSET=0x0000
  ICCARM.CCIncludePath2: ; ..\..; ..\..\vsf_cfg; ..\..\..\..; ..\..\..\..\compiler\IAR; ..\..\..\..\interfaces; ..\..\..\..\interfaces\cpu\nuc400
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: nuc400.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FLASH_LOAD_OFFSET=0x00010200
  ICCARM.CCDiagSuppress: Pa050,Pe301
  ICCARM.CCIncludePath2: ; ..\..; ..\..\vsf_cfg; ..\..\..\..; ..\..\..\..\compiler\IAR; ..\..\..\..\interfaces; ..\..\..\..\interfaces\cpu\nuc400; ..\..\..\..\interfaces\cpu\nuc400\core
  ICCARM.CCOptLevel: 1
  ILINK.IlinkIcfFile: nuc400_booted.icf
  group (top)
    ./: app_cfg.h interfaces_cfg.h interfaces_cfg_nuc400.h vsf_cfg.h
    ../../: recovery.c recovery.h usbd_config.c usrapp.c usrapp.h
  group shell_cmd
    shell_cmd/: cdcuart.c cdcuart.h help.c help.h ota.c ota.h
  group vsf
    ../../../../: vsfmain.c
  group vsf/component/buffer
    ../../../../component/buffer/: buffer.c buffer.h
  group vsf/component/list
    ../../../../component/list/: list.c list.h
  group vsf/component/stream
    ../../../../component/stream/: stream.c stream.h
  group vsf/dal/usart_stream
    ../../../../dal/usart_stream/: usart_stream.c usart_stream.h
  group vsf/framework/vsfshell
    ../../../../framework/vsfshell/: vsfshell.c vsfshell.h
  group vsf/framework/vsfsm
    ../../../../framework/vsfsm/: vsfsm.c
  group vsf/framework/vsftimer
    ../../../../framework/vsftimer/: vsftimer.c
  group vsf/interfaces
    ../../../../interfaces/: interfaces.c interfaces.h
  group vsf/interfaces/cpu/nuc400
    ../../../../interfaces/cpu/nuc400/: core.c core.h interfaces_const.h NUC472_442.h vsf_basetype.h
    ../../../../interfaces/cpu/nuc400/startup/IAR/: startup_NUC472_442.s
  group vsf/interfaces/cpu/nuc400/flash
    ../../../../interfaces/cpu/nuc400/flash/: NUC400_FLASH.c NUC400_FLASH.h
  group vsf/interfaces/cpu/nuc400/gpio
    ../../../../interfaces/cpu/nuc400/gpio/: NUC400_GPIO.c NUC400_GPIO.h
  group vsf/interfaces/cpu/nuc400/uart
    ../../../../interfaces/cpu/nuc400/uart/: NUC400_USART.c NUC400_USART.h
  group vsf/interfaces/cpu/nuc400/usbd
    ../../../../interfaces/cpu/nuc400/usbd/: NUC400_USBD.c NUC400_USBD.h
  group vsf/stack/usb/class/device/CDC
    ../../../../stack/usb/class/device/CDC/: vsfusbd_CDC.c vsfusbd_CDC.h vsfusbd_CDCACM.c vsfusbd_CDCACM.h
  group vsf/stack/usb/common
    ../../../../stack/usb/common/: usb_ch11.h usb_ch9.h usb_common.h usb_type.h
  group vsf/stack/usb/core
    ../../../../stack/usb/core/: vsfusbd.c vsfusbd.h
  group vsf/tool/bittool
    ../../../../tool/bittool/: bittool.c
  group vsf/tool/crc
    ../../../../tool/crc/: crc.c crc.h
