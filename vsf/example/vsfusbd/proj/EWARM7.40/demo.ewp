# IAR project demo.ewp, settings and files
configuration CME-M7_Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: FLASH_LOAD_OFFSET=0x08000000; BOARD_TYPE_TEST_CMEM7
  ICCARM.CCDiagSuppress: Pa050,Pe301
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..; ..\..\..\..\compiler\IAR; ..\..\..\..\hal; ..\..\..\..\hal\cpu\cmem7
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: cme_m7.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CME-M7_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: NUC505 series Nuvoton NUC505 series
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; FLASH_LOAD_OFFSET=0x0; _HARDWARE_VER=VLlinkR2
  ICCARM.CCIncludePath2: ; ..\..; ..\..\config; ..\..\..\..; ..\..\..\..\compiler\IAR; ..\..\..\..\hal; ..\..\..\..\hal\cpu\nuc505
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  ILINK.IlinkIcfFile: nuc505.icf
  group (top)
    ../../: usrapp.c usrapp.h
  group proj
    ../: app_cfg.h vsf_cfg.h vsfhal_cfg.h vsfhal_cfg_test_cmem7.h
  group vsf
    ../../../../: vsf.h vsf_err.h vsfmain.c
  group vsf/compiler
    ../../../../compiler/IAR/: compiler.c compiler.h
  group vsf/component/crypto/crc
    ../../../../component/crypto/crc/: crc.c crc.h
  group vsf/component/debug
    ../../../../component/debug/: vsfdbg.c vsfdbg.h
  group vsf/component/file
    ../../../../component/file/: vsfile.c vsfile.h
  group vsf/component/file/fs/fakefs/fakefat32
    ../../../../component/file/fs/fakefs/fakefat32/: fakefat32.c fakefat32.h
  group vsf/component/file/fs/malfs
    ../../../../component/file/fs/malfs/: vsf_malfs.c vsf_malfs.h
  group vsf/component/file/fs/malfs/fat
    ../../../../component/file/fs/malfs/fat/: vsffat.c vsffat.h
  group vsf/component/fundation/bittool
    ../../../../component/fundation/bittool/: bittool.c bittool.h
  group vsf/component/fundation/buffer
    ../../../../component/fundation/buffer/: buffer.c buffer.h
  group vsf/component/fundation/list
    ../../../../component/fundation/list/: list.c list.h
  group vsf/component/fundation/stream
    ../../../../component/fundation/stream/: stream.c stream.h
  group vsf/component/mal
    ../../../../component/mal/: vsfmal.c vsfmal.h vsfscsi.c vsfscsi.h
  group vsf/component/mal/drivers/embflash
    ../../../../component/mal/drivers/embflash/: embflash.c embflash.h
  group vsf/component/shell
    ../../../../component/shell/: vsfshell.c vsfshell.h
  group vsf/component/stream/usart_stream
    ../../../../component/stream/usart_stream/: usart_stream.c usart_stream.h
  group vsf/component/tool/dynarr
    ../../../../component/tool/dynarr/: vsf_dynarr.c vsf_dynarr.h
  group vsf/component/tool/dynpool
    ../../../../component/tool/dynpool/: vsf_dynpool.c vsf_dynpool.h
  group vsf/component/tool/dynstack
    ../../../../component/tool/dynstack/: vsf_dynstack.c vsf_dynstack.h
  group vsf/component/usb/class/common/CDC
    ../../../../component/usb/class/common/CDC/: vsfusb_CDC.h vsfusb_CDCACM.h vsfusb_RNDIS.h
  group vsf/component/usb/class/common/MSC
    ../../../../component/usb/class/common/MSC/: vsfusb_MSC.h
  group vsf/component/usb/class/device/CDC
    ../../../../component/usb/class/device/CDC/: vsfusbd_CDC.c vsfusbd_CDC.h vsfusbd_CDCACM.c vsfusbd_CDCACM.h vsfusbd_RNDIS.c vsfusbd_RNDIS.h
  group vsf/component/usb/class/device/HID
    ../../../../component/usb/class/device/HID/: vsfusbd_HID.c vsfusbd_HID.h
  group vsf/component/usb/class/device/MSC
    ../../../../component/usb/class/device/MSC/: vsfusbd_MSC_BOT.c vsfusbd_MSC_BOT.h
  group vsf/component/usb/class/host/HID
    ../../../../component/usb/class/host/HID/: vsfusbh_HID.c vsfusbh_HID.h
  group vsf/component/usb/class/host/HUB
    ../../../../component/usb/class/host/HUB/: vsfusbh_HUB.c vsfusbh_HUB.h
  group vsf/component/usb/class/host/UVC
    ../../../../component/usb/class/host/UVC/: vsfusbh_UVC.c vsfusbh_UVC.h
  group vsf/component/usb/common
    ../../../../component/usb/common/: usb_ch11.h usb_ch9.h usb_common.c usb_common.h usb_type.h
  group vsf/component/usb/core
    ../../../../component/usb/core/: vsfusbd.c vsfusbd.h vsfusbh.c vsfusbh.h
  group vsf/component/usb/core/dwc_otg
    ../../../../component/usb/core/dwc_otg/: dwcotg_regs.h vsfdwcotg.c vsfdwcotg.h vsfdwcotg_priv.h
  group vsf/component/usb/core/hcd
    ../../../../component/usb/core/hcd/: hcd.h
  group vsf/component/usb/core/hcd/ohci
    ../../../../component/usb/core/hcd/ohci/: vsfohci.c vsfohci.h vsfohci_priv.h
  group vsf/framework/vsfsm
    ../../../../framework/vsfsm/: vsfsm.c vsfsm.h
  group vsf/framework/vsftimer
    ../../../../framework/vsftimer/: vsftimer.c vsftimer.h
  group vsf/hal
    ../../../../hal/: vsfhal.c vsfhal.h
  group vsf/hal/cpu/cmem7
    ../../../../hal/cpu/cmem7/: cmem7.h core.c core.h core_cm3.h vsf_basetype.h vsfhal_const.h
  group vsf/hal/cpu/cmem7/startup
    ../../../../hal/cpu/cmem7/startup/iar/: startup_cmem7.s
  group vsf/hal/cpu/cmem7/usb
    ../../../../hal/cpu/cmem7/usb/: CMEM7_USB.c CMEM7_USB.h
  group vsf/hal/cpu/cmem7/usbd
    ../../../../hal/cpu/cmem7/usbd/: CMEM7_USBD.c CMEM7_USBD.h
  group vsf/hal/cpu/stm32f4
    ../../../../hal/cpu/stm32f4/: core.c core.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f401xc.h stm32f401xe.h stm32f405xx.h stm32f407xx.h stm32f410cx.h stm32f410rx.h stm32f410tx.h stm32f411xe.h stm32f415xx.h stm32f417xx.h stm32f427xx.h stm32f429xx.h stm32f437xx.h stm32f439xx.h stm32f446xx.h stm32f469xx.h stm32f479xx.h stm32f4xx.h vsf_basetype.h vsfhal_const.h
  group vsf/hal/cpu/stm32f4/startup
    ../../../../hal/cpu/stm32f4/startup/iar/: startup_stm32f411xe.s
  group vsf/hal/cpu/stm32f4/usb
    ../../../../hal/cpu/stm32f4/usb/: usb.c usb.h
  group vsf/hal/cpu/stm32f7
    ../../../../hal/cpu/stm32f7/: core.c core.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f722xx.h stm32f723xx.h stm32f732xx.h stm32f733xx.h stm32f745xx.h stm32f746xx.h stm32f756xx.h stm32f765xx.h stm32f767xx.h stm32f769xx.h stm32f777xx.h stm32f779xx.h stm32f7xx.h vsf_basetype.h vsfhal_const.h
  group vsf/hal/cpu/stm32f7/startup
    ../../../../hal/cpu/stm32f7/startup/iar/: startup_stm32f769xx.s
  group vsf/hal/cpu/stm32f7/usb
    ../../../../hal/cpu/stm32f7/usb/: usb.c usb.h
