# Keil uVision project cmem7.uvproj, settings and files
target M7 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: M7 Capital Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: cmem7 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: FLASH_LOAD_OFFSET=0x08000000 BOARD_TYPE_TEST_CMEM7
  c misc: --gnu
  c include: ..;..\..;..\..\..\..;..\..\..\..\compiler\ARMCC;..\..\..\..\hal;..\..\..\..\hal\cpu\cmem7
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group proj
    ../: app_cfg.h vsf_cfg.h vsfhal_cfg.h vsfhal_cfg_nucleo_f411re.h vsfhal_cfg_test_cmem7.h
    ../../: usrapp.c usrapp.h
  group vsf
    ../../../../: vsf.h vsf_err.h vsf_type.h vsfmain.c
    ../../../../compiler/ARMCC/: compiler.c compiler.h
    ../../../../framework/vsfsm/: vsfsm.c vsfsm.h
    ../../../../framework/vsftimer/: vsftimer.c vsftimer.h
  group vsf_component
    ../../../../component/fundation/bittool/: bittool.c bittool.h
    ../../../../component/fundation/buffer/: buffer.c buffer.h
    ../../../../component/fundation/list/: list.c list.h
    ../../../../component/fundation/stream/: stream.c stream.h
    ../../../../component/tool/dynarr/: vsf_dynarr.c vsf_dynarr.h
    ../../../../component/tool/dynpool/: vsf_dynpool.c vsf_dynpool.h
    ../../../../component/tool/dynstack/: vsf_dynstack.c vsf_dynstack.h
    ../../../../component/usb/class/host/HUB/: vsfusbh_HUB.c vsfusbh_HUB.h
    ../../../../component/usb/class/host/UVC/: vsfusbh_UVC.h vsfusbh_UVC.c
    ../../../../component/usb/common/: usb_ch9.h usb_ch11.h usb_common.c usb_common.h usb_type.h
    ../../../../component/usb/core/: vsfusbh.c vsfusbh.h
    ../../../../component/usb/core/dwc_otg/: dwcotg_regs.h vsfdwcotg.c vsfdwcotg.h vsfdwcotg_priv.h
  group vsf_hal
    ../../../../hal/: vsfhal.c vsfhal.h
    ../../../../hal/cpu/cmem7/: cmem7.h core.c core.h vsf_basetype.h vsfhal_const.h
    ../../../../hal/cpu/cmem7/startup/: startup_cmem7.s
    ../../../../hal/cpu/cmem7/usb/: CMEM7_USB.c CMEM7_USB.h
